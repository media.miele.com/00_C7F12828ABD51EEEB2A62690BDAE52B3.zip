Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 9a5fc78f-6a3e-440e-9c70-ef3f261dbf76, NumberOfSaves: 1]
File name: 0001
Time: 2024-02-06T08:22:59+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12526060_F_DA9092W_OBSW:28909240_F_12526060_DA9092W_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass, z_Miele_Design_Zinc_Steel, Aluminum, z_Miele_Design_OBSW, z_Miele_Connection_ExhaustAir, <Unnamed>, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 28909240_F_12526060_DA9092W_OBSW; sets with these values: 2
Pset_ProvisionForVoid - Width: 880 mm; Height: 500 mm; Depth: 260 mm

# IfcDistributionPort, Port_353377_1
Description: Flow; FlowDirection: SOURCEANDSINK
